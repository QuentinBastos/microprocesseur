# Keil uVision project Projet_TP2.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP2_IRC_Sim
  c flags: SizeSpeed=1
  group Programmes Source 1
    ./: STARTUP.A51 Lib_Base.c TP1_Lib_ASM.ASM Main_TP2.C
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP2_IRC
  c flags: SizeSpeed=1
