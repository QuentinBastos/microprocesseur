# Keil uVision project TP1_Archi_3IRC.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP1_3IRC_SIM
  c flags: SizeSpeed=1
  group Programmes source 1
    ./: STARTUP.A51 TP1_Main.c
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP1_3IRC_EXE
  c flags: SizeSpeed=1
